# Keil uVision project debouncer_example.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: debouncer_example_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c lib_debounce.c
    ../../../../Source/: keil_arm_uv4.lnt
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: debouncer_example_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: as above
  output: debouncer_example_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: debouncer_example_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
